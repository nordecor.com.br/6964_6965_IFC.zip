Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-11-06T12:06:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 06 12:06:35 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\3493653e-7bdc-4db9-89a7-ea952fc60c1c\2d17d097-3160-41ed-af31-c1cd924d4dd5\ifc * Database version: 5507 * Database creation date: Thu Nov 06 12:06:35 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 06 12:06:35 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 06 12:06:35 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6964, Spot_BletLite_6964_6965_Nordecor_IFC:6964:329856
In: Nível 1
Type - Material: LED, Metal - Alumínio - Branco, Plástico - Transparente
Type - Cotas - Altura do Spot: 93 mm; Altura total: 128 mm; Diâmetro da base: 25 mm; Diâmetro do spot: 16 mm
Type - Dados - Data de atualização: 03/11/2025; Versão: 1
Type - Dados de identidade - Código Uniformat: D5020.20; Comentários de tipos: sspot de sobrepor BLET LITE, acabamento branco ou preto, LED 1W, 2700K, facho 30°, iluminação pontual, uso interno, design minimalista, foco de destaque; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Spot de sobrepor BLET LITE acabamento branco, LED 1W 2.700K 30º; Descrição UniFormat: Luminárias integradas ao edifício; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 0; Localização: Itajaí/SC - Brasil; Modelo: 6964; Nome do tipo: 6964; Nota-chave: 26 56 33.15; Número MasterFormat: 26 56 33; Número OmniClass: 23.80.70.14.14; Tipo de imagem: Imagem raster: 6964.png; Tipo de luminária: Distribuição Direta / Facho Fechado; Título MasterFormat: Luminárias de Montagem em Superfície; Título OmniClass: Exterior Floodlights; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/
Type - Elétrico - Comentários de voltagem: 100-240V; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente: 0 W; Carga aparente da luminária: 0 W
Type - Engenharia elétrica - Fator de potência da luminária: 0; Voltagem da Luminária: 0 V
Type - Estrutural - Peso da luminária: 0
Type - Fotométricos - Ângulo de abertura: 30 deg; Fluxo luminoso: 288.65 lm; IRC: 97; Potência: 1 W; Temperatura da cor: 3000 K; UGR: 0
Type - Materiais e acabamentos - Difusor: Plástico - Transparente; Spot: Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Spot_BletLite_6964_6965_Nordecor_IFC; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6964; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.00554047 m2; Inclinação do spot: 0 deg; Rotação do spot: 0 deg; Volume: 0.0000161016 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Spot_BletLite_6964_6965_Nordecor_IFC: 6964; Família e tipo: Spot_BletLite_6964_6965_Nordecor_IFC: 6964; ID de tipo: Spot_BletLite_6964_6965_Nordecor_IFC: 6964; Tipo: Spot_BletLite_6964_6965_Nordecor_IFC: 6964
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
